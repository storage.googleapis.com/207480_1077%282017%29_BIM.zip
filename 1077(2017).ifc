Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-05-11T11:02:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 11 11:02:06 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{C53A6C4F-499E-4815-A9C8-674BB646BB1A}\ifc * Database version: 5507 * Database creation date: Fri May 11 11:02:04 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 11 11:02:04 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 11 11:02:04 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowController: 1077 Utility room faucet, 1077(2017):1077 Utility room faucet:307794
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Pset_ManufacturerTypeInformation - ModelReference: 1077; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1077 Utility room faucet
